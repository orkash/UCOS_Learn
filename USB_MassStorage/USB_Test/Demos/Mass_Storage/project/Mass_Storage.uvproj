# Keil uVision project Mass_Storage.uvproj, settings and files
target Mass_Storage (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Mass_Storage
  c flags: Optim=1
  c define: USE_STM3210E_EVAL
  c include: ..\..\..\..\common\inc;..\..\..\USBLIB\inc;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../../../../common/startup/: stm32f10x_vector.s
  group Application Files
    ../src/: fsmc_nand.c hw_config.c main.c mass_mal.c memory.c msd.c nand_if.c scsi_data.c sdcard.c stm32f10x_dma.c stm32f10x_it.c stm32f10x_sdio.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group USBLIB
    ../../../USBLIB/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group Common Files
    ../../../../common/src/: stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_rcc.c cortexm3_macro.s stm32f10x_systick.c spi_flash.c lcd.c stm32f10x_spi.c stm32f10x_fsmc.c
  group Read me
    ../Read_me/: readme.txt
