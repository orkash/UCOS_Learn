# Keil uVision project OSReadBoard.uvproj, settings and files
target OSReadBoard (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: OSReadBoard
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\app\inc;..\UCOSII\CORE;..\UCOSII\PORT;..\UCOSII\CONFIG;..\STM32_USB-FS-Device_Driver\inc;..\STM32F10x_FWLib\inc;..\HARDWARE\inc;..\FATFS\inc;..\CORE;..\FATFS\exfuns;.\app\USB_Device
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./app/src/: stm32f10x_it.c system_stm32f10x.c app.c
  group USB_Device
    ./app/USB_Device/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c hw_config.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USB_FS
    ../STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group uC/OS-II CORE
    ../UCOSII/CORE/: OS_CORE.C OS_FLAG.C OS_MBOX.C OS_MEM.C OS_MUTEX.C OS_Q.C OS_SEM.C OS_TASK.C OS_TIME.C
  group uC/OS-II PORT
    ../UCOSII/PORT/: os_cpu_a.asm os_cpu_c.c
  group uC/OS-II CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
