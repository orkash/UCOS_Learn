# IAR project HD-863-2013.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\Drivers\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Drivers\CMSIS\Device\ST\STM32F10x\Include; ..\..\..\Drivers\BSP\HD-863-2013\inc; ..\..\..\Middlewares\ST\STM32_USB-FS-Device_Driver\inc; ..\..\..\Middlewares\Third_Party\UCOSII\CORE; ..\..\..\Middlewares\Third_Party\UCOSII\PORT\IAR; ..\..\..\Middlewares\Third_Party\UCOSII\CONFIG; ..\app\inc; ..\..\..\Middlewares\Third_Party\FatFs\src; ..\..\..\Middlewares\ST\STemWin\inc; ..\..\..\Middlewares\ST\STemWin\Config; ..\..\..\Middlewares\ST\STemWin\Demo
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HD-863-2013.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group App
    ../app/src/: app.c memory.c stm32f10x_it.c sys_about.c task.c word.c
  group Doc
    ../: readme.txt
  group Drivers/BSP
    ../../../Drivers/BSP/HD-863-2013/src/: drivers.c
  group Drivers/CMSIS
    ../../../Drivers/CMSIS/Device/ST/STM32F10x/Source/: core_cm3.c
    ../../../Drivers/CMSIS/Device/ST/STM32F10x/Source/Templates/iar/: startup_stm32f10x_hd.s
    ../../../Drivers/CMSIS/Device/ST/STM32F10x/Source/Templates/: system_stm32f10x.c
  group Drivers/STM32F10x_StdPeriph_Driver
    ../../../Drivers/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Middlewares/FatFs/Core
    ../../../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c
  group Middlewares/STemWin/Config
    ../../../Middlewares/ST/STemWin/Config/: GUIConf.c
    ../app/src/: LCDConf_FlexColor.c
  group Middlewares/STemWin/demo
    ../../../Middlewares/ST/STemWin/Demo/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group Middlewares/STemWin/Lib
    ../../../Middlewares/ST/STemWin/Lib/: STemWin522_CM3_OS_IAR.a
  group Middlewares/STemWin/OS
    ../../../Middlewares/ST/STemWin/OS/: GUI_X_uCosii.c
  group Middlewares/uCosII/CONFIG
    ../../../Middlewares/Third_Party/UCOSII/CONFIG/: includes.h os_cfg.h
  group Middlewares/uCosII/CORE
    ../../../Middlewares/Third_Party/UCOSII/CORE/: uCOS_II.C
  group Middlewares/uCosII/PORT
    ../../../Middlewares/Third_Party/UCOSII/PORT/IAR/: os_cpu_a.asm os_cpu_c.c
